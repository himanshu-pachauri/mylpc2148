# Keil uVision project blk.uvproj, settings and files
target Target 1 (MCS-51)
  device: see NXP Philips
  output: blk
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: blk.c
